# Repository hospadar/ShutterSpeedCalibrator

## KiCad design pcb/pcb_for_Polaroid/ShutterCal_Polaroid/ShutterCal_Polaroid.kicad_pcb

Parts:
C1: 0.75pF; C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
C3, C5, C8, C9: 100nF; C_0603_1608Metric
C4: 4.7uF; C_0603_1608Metric
C6, C7: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SFH2440; Osram_SFH2440
D2: SMF5V0A; D_SMF
F1: 0.5A PPTC; Fuse_1206_3216Metric
J1: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2, J4, J5: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J6, J9: Conn_01x04_Shielded; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal
J7: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
R1: 240k; R_0603_1608Metric
R2: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 6.8k; R_0603_1608Metric
R5: 330k; R_0603_1608Metric
R6, R7: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1: REF0; TestPoint_Pad_D1.5mm
U1: OPA365AIDBVR; SOT-23-5
U2: STM32G030F6Px; TSSOP-20_4.4x6.5mm_P0.65mm
U3: CH340N; SOP-8_3.9x4.9mm_P1.27mm
U4: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3V: C3.1, C4.1, C6.1, C8.1, C9.1, J2.4, J4.1, J5.1, J6.1, J9.1, R8.2, U2.4 (VDD), U3.5 (VCC), U3.8 (V3), U4.2 (VO)
+5V: C7.1, D2.1 (A1), F1.2, R5.2, U1.5 (V+), U4.3 (VI)
/5V_IN: F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), J7.1
/ADC1_IN6: R2.2, R3.1, U2.13 (PA6)
/ADC1_IN7: R8.1, U2.14 (PA7)
/I2C2_SCL: J4.2, J9.2, U2.16 (PA11/PA9)
/I2C2_SDA: J4.3, J9.3, U2.17 (PA12/PA10)
/Light_out: C1.2, J1.1 (In), R1.2, R2.1, U1.1
/NRST: C5.2, JP1.2 (B), U2.6 (NRST)
/SWCLK: J2.2, U2.19 (PA14/PA15)
/SWDIO: J2.3, U2.18 (PA13)
/UART1_RX: U2.1 (PB7/PB8), U3.6 (TXD)
/UART1_TX: U2.20 (PB3/PB4/PB5/PB6), U3.7 (RXD)
/UART2_RX: J5.3, J6.3, U2.10 (PA3)
/UART2_TX: J5.2, J6.2, U2.9 (PA2)
/USB+: J3.A6 (D+), J3.B6 (D+), U3.1 (UD+)
/USB-: J3.A7 (D-), J3.B7 (D-), U3.2 (UD-)
GND: C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, D1.2 (A), D2.2 (A2), J1.2 (Ext), J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.4, J5.4, J6.4, J6.SH (Shield), J7.2, J9.4, J9.SH (Shield), JP1.1 (A), R3.2, R4.1, R6.2, R7.2, U1.2 (V-), U2.5 (VSS), U3.3 (GND), U4.1 (GND)
unnamed: C1.1, D1.1 (K), R1.1, U1.4 (-)
unnamed: J3.A5 (CC1), R6.1
unnamed: J3.B5 (CC2), R7.1
unnamed: C2.1, R4.2, R5.1, TP1.1, U1.3 (+)

Notes on the sheet:
光电二级管
USB串口

Board: 2 copper layers, 84.7 x 87.0 mm, 34 parts (33 on the bottom side), 22 nets.

File pcb/pcb_for_Polaroid/ShutterCal_Polaroid/production_jlc/BOM_JLC.csv:

Comment,Designator,Footprint,LCSC Part #
0.75pF,C1,C_0603_1608Metric,C95182
1uF,C2,C_0603_1608Metric,C15849
100nF,"C3,C5,C8,C9",C_0603_1608Metric,C14663
4.7uF,C4,C_0603_1608Metric,C19666
22uF,"C6,C7",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C45783
SMF5V0A,D2,D_SMF,C1972946
0.5A PPTC,F1,Fuse_1206_3216Metric,C163512
USB_C_Receptacle_USB2.0,J3,USB_C_Receptacle_HRO_TYPE-C-31-M-12,C165948
240k,R1,R_0603_1608Metric,C4197
100k,R2,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C149504
150k,R3,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C17470
6.8k,R4,R_0603_1608Metric,C23212
330k,R5,R_0603_1608Metric,C23137
5.1k,"R6,R7",R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C27834
1k,R8,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C17513
OPA365AIDBVR,U1,SOT-23-5,C96626
STM32G030F6Px,U2,TSSOP-20_4.4x6.5mm_P0.65mm,C529330
CH340N,U3,SOP-8_3.9x4.9mm_P1.27mm,C2977777
AMS1117-3.3,U4,SOT-223-3_TabPin2,C6186
